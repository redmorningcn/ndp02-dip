# Keil uVision project uCOS-II-test.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.3.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: uCOS-II-test +hex
  AfterMake: fromelf --bin !L --output iap1000.bin
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\uCOS-II;.\uCOS-II;.\uCOS-II\Ports;.\uCOS-II\Ports\ARM-Cortex-M3\Generic\RealView;.\uCOS-II\Source;.\App;.\CSB\include;.\APP_TEST;.\APP_TEST\MX25L1602Drv;.\APP_TEST;.\APP_TEST\OCM800600T80;.\uCGUI;.\uCGUI\GUI\AntiAlias;.\uCGUI\GUI\ConvertColor;.\uCGUI\GUI\ConvertMono;.\uCGUI\GUI\Core;.\uCGUI\GUI\Font;.\uCGUI\GUI\JPEG;.\uCGUI\GUI\LCDDriver;.\uCGUI\GUI\MemDev;.\uCGUI\GUI\MultiLayer;.\uCGUI\GUI\Widget;.\uCGUI\GUI\WM;.\uCGUI\Config;..\DipSoftware\Globe;..\DipSoftware\DataDealTask;..\DipSoftware\CardOperateTask;..\DipSoftware\DataDealTask;..\DipSoftware\HoldTask;..\DipSoftware\MastConTask;..\DipSoftware\SlaveConTask
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group uCOS_II_Source
    ./uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS_II_Port
    ./uCOS-II/Ports/ARM-Cortex-M3/RealView/: os_dbg.c os_cpu_a.asm os_cpu_c.c
  group App
    ./: app.c app_hooks.c
  group BSP
    ./BSP/: startup_LPC17xx.s system_LPC17xx.c
  group CSP
    ./CSB/source/: debug_frmwrk.c lpc17xx_adc.c lpc17xx_can.c lpc17xx_clkpwr.c lpc17xx_dac.c lpc17xx_emac.c lpc17xx_exti.c lpc17xx_gpdma.c lpc17xx_i2c.c lpc17xx_i2s.c lpc17xx_iap.c lpc17xx_libcfg_default.c lpc17xx_mcpwm.c lpc17xx_nvic.c lpc17xx_pinsel.c lpc17xx_pwm.c lpc17xx_qei.c lpc17xx_rit.c lpc17xx_rtc.c lpc17xx_spi.c lpc17xx_ssp.c lpc17xx_systick.c lpc17xx_timer.c lpc17xx_uart.c lpc17xx_wdt.c lpc17xx_gpio.c
  group APP_TEST
    ./APP_TEST/: GPIO_Test.c GPIO_APP.c UART1.c UART2.c UART3.c UART0001.c UART0002.c UART0.c timer.c
    ./APP_TEST/MX25L1602Drv/: MX25L1602Drv.c
    ../DipSoftware/HoldTask/: ADC.c
  group APP_Globe
    ../DipSoftware/Globe/: CrcCheck.c FIFO.c GlobePara.c
  group APP_MastCon
    ../DipSoftware/MastConTask/: GetDipPrs.c power.c DipComOperate.c
  group tmp
    ./: tmp.c
  group APP_SlaveCon
    ../DipSoftware/SlaveConTask/: Tax2.c RS485 .c csnr.c cnsccomdeal.c cnscpackdeal.c
  group APP_HoldTast
    ../DipSoftware/DataDealTask/: FramStore.c
    ../DipSoftware/HoldTask/: Display.c DS3231.c Led.c WatchDog.C IIC.c SoftSpi_17xx.c
  group APP_DataDeal
    ../DipSoftware/DataDealTask/: FRAM.c DealOilBox.c StoreRec.c MathDipVal.c RecModel.c
  group APP_CardOperate
    ../DipSoftware/CardOperateTask/: Card.c DataCard.c OperateCard.c ParaCard.c CardTest.c
  group APP_EquipmentOperate
    ../DipSoftware/EquipmentOperate/: EquimentOperate.c EquimentCom.c
  group speed
    ../DipSoftware/speed/: storespeed.C speed1.C speed2.C mstcsspeed.C locoworksta.C
software components: CMSIS:CORE 5.0.1
